# Keil uVision project oled_demo.uvprojx, settings and files
target oled_demo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: oled_demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\User\OLED;..\User\GUI;..\User\Config;..\User\Fonts;..\User\Example
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c gpio.c i2c.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Example
    ../User/Example/: ImageData.c OLED_0in91_test.c OLED_0in95_rgb_test.c OLED_0in96_test.c OLED_0in96_rgb_test.c OLED_1in27_rgb_test.c OLED_1in3_test.c OLED_1in3_c_test.c OLED_1in32_test.c OLED_1in5_test.c OLED_1in5_b_test.c OLED_1in5_rgb_test.c OLED_1in51_test.c OLED_1in54_test.c OLED_2in42_test.c
  group OLED
    ../User/OLED/: OLED_0in91.c OLED_0in95_rgb.c OLED_0in96.c OLED_0in96_rgb.c OLED_1in27_rgb.c OLED_1in3.c OLED_1in3_c.c OLED_1in32.c OLED_1in5.c OLED_1in5_b.c OLED_1in5_rgb.c OLED_1in51.c OLED_1in54.c OLED_2in42.c
  group GUI
    ../User/GUI/: GUI_Paint.c
  group Config
    ../User/Config/: DEV_Config.c Soft_IIC.c
  group Fonts
    ../User/Fonts/: font8.c font12.c font16.c font20.c font24.c font12CN.c font24CN.c
software components: CMSIS:CORE 4.3.0
